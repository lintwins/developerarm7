# Keil uVision project Uart_Int.uvproj, settings and files
target Uart_Int (ARM-ADS)
  device: LPC2368 NXP (founded by Philips)
  cpu: IRAM(0x40000000-0x40007FFF) IRAM2(0x7FE00000-0x7FE037FF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: Uart_Int +hex
  c flags: Optim=1
  c define: __DEBUG_FLASH
  c include: .\Inc;..\..\SDK\inc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  memory RVCT10: RAM 0x7fe00000 size 0x3800
  group Startup Code
    ../../SDK/src/: LPC2300.s target.c irq.c
  group Source Code
    ./Src/: main.c uart.c
